Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2026-04-08T16:13:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 16:13:04 2026 * Host: Yoga * Database: D:\Temp\fc611c4b-5023-439d-9981-df5257fdc4ad\9978d10e-7c62-47da-83d4-e31f3fa5de4b\ifc * Database version: 5507 * Database creation date: Wed Apr 08 16:13:00 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 16:13:01 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 16:13:01 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum

# IfcFlowTerminal: AL0220:AL0220, AL0220:AL0220:1094368
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: AL0220
Type - Other - Category: Plumbing Fixtures; Family Name: AL0220
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: AL0220:AL0220; sets with these values: 2
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.00000628277 m2; Volume: 3.1402e-09 m3
Identity Data - Mark: 652
Other - Family: AL0220: AL0220; Family and Type: AL0220: AL0220; Type: AL0220: AL0220; Type Id: AL0220: AL0220
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer, BC2008:BC2008 Dolphin Slimline Eco Hand Dryer:356950
In: Level 0
Type - Classification: D2010900 Other Plumbing Fixtures (Uniformat); Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 101 mm; Height: 270.2 mm; Width: 161.4 mm
Type - Identity Data - AccessibilityPerformance: n/a; Assembly Code: D2010900; Assembly Description: Other Plumbing Fixtures; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP24; Category: Pr_40_70_62_37:Hand dryers; CodePerformance: n/a; Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyPowerRating: 500-900 W; ElectricalSupplyRatedOperationalVoltage: 220-240 V a.c; ExpectedLife: n/a; Features: Touch free; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: High-velocity air; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: Dolphin Solutions Limited; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: n/a; Model: BC2008; ModelNumber: BC2008/ BC2008W; ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; NBSDescription: Hand dryers; NBSReference: 45-35-72/334; NBSTypeID: n/a; NoiseLevelAt1MMaximum: 76.6 dB(A); NominalHeight: 270; NominalLength: 101; NominalWidth: 162; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.14; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-mini-hand-dryer-bc2008/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 162 x 270 x 101 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC2008 Dolphin Slimline Eco Hand Dryer; Uniclass2015Code: Pr_40_70_62_37; Uniclass2015Title: Hand dryers; URL: www.dolphinsolutios.co.uk; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC2008
Type - Pset_ElementShading - Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Manufacturer: Dolphin Solutions Limited
Type - Pset_ProductRequirements - Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; Category: Pr_40_70_62_37:Hand dryers
Pset_DistributionFlowElementCommon - Reference: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0910884 m2; Volume: 0.0043877 m3
Identity Data - Mark: 10
Other - Family: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Family and Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type Id: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC238SS:BC238SS, BC238SS:BC238SS:1094360
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103.5 mm; Height: 286 mm; Width: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 1000 ml; Category: Pr_40_70_22_81:Soap dispensers; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Wall mounted soap or sanitiser dispenser; DurationUnit: year; ElectricalSupplyPowerRating: 4 x C cell batteries; ElectricalSupplyRatedOperationalVoltage: Optional3VMainSupply; ExpectedLife: n/a; Features: TouchFree_Liquid_or_Sanitiser_Cartridge; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC238SS; ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; NBSDescription: Soap dispensers; NBSReference: 45-35-72/358; NBSTypeID: n/a; NominalHeight: 268; NominalLength: 104; NominalWidth: 125; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.34; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-auto-soap-sanitiser-dispenser/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 125 x 268 x 104 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC238SS; Uniclass2015Code: Pr_40_70_22_81; Uniclass2015Title: Soap dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC238SS
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; Category: Pr_40_70_22_81:Soap dispensers
Pset_DistributionFlowElementCommon - Reference: BC238SS:BC238SS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 799 mm; Host: Level : Level 0; Offset from Host: 799 mm
Dimensions - Area: 0.0782756 m2; Volume: 0.00369491 m3
Identity Data - Mark: 644
Other - Family: BC238SS: BC238SS; Family and Type: BC238SS: BC238SS; Type: BC238SS: BC238SS; Type Id: BC238SS: BC238SS
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC4302:BC4302, BC4302:BC4302:356951
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Width: 145.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_88:Toilet roll holders; CodePerformance: n/a; Color: Brushed Satin/ BC4302B_Polished; Constituents: n/a; Description: Toilet tissue dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Bulk Pack Tissue; Finish: Brushed Satin/ Polished_BC4302B; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC4302/BC4302B; ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; NBSDescription: Toilet roll holders; NBSReference: 45-35-72/366; NBSTypeID: n/a; NominalHeight: 240 mm; NominalLength: 111 mm; NominalWidth: 145 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.21; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-tissue-dispenser-bc4302/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 145 x 240 x 111 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC4302; Uniclass2015Code: Pr_40_20_76_88; Uniclass2015Title: Toilet roll holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC4302
Type - Pset_ElementShading - Color: Brushed Satin/ BC4302B_Polished
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; Category: Pr_40_20_76_88:Toilet roll holders
Pset_DistributionFlowElementCommon - Reference: BC4302:BC4302; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0829836 m2; Volume: 0.00350184 m3
Identity Data - Mark: 11
Other - Family: BC4302: BC4302; Family and Type: BC4302: BC4302; Type: BC4302: BC4302; Type Id: BC4302: BC4302
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-02:Standard (4)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm long 32mm Grab Rail 75mm Rosettes; DurationUnit: year; ExpectedLife: n/a; Features: 50mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-02; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 82 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-grab-rail-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 82 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-02
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5083-02:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0760405 m2; Volume: 0.000185759 m3
Other - Family: BC5083-02: Standard; Family and Type: BC5083-02: Standard; Type: BC5083-02: Standard; Type Id: BC5083-02: Standard
Phasing - Phase Created: New Construction
Name (BC5083-02:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356943 | 1100 | 3
356945 | 1100 | 5
356946 | 1100 | 6
356947 | 664 | 7

# IfcFlowTerminal: BC5083-06:DP670300, BC5083-06:DP670300:356942
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 800 mm; Height: 203 mm; Width: 153 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin; Constituents: n/a; Description: 800mm Hinged Fold Down Grab Rail; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-06; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldHingedDown32mmGrabRail_BC5083-06_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 203 mm; NominalLength: 800 mm; NominalWidth: 153 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-friction-hinged-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 153 x 203 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP670300; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-06
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SupportRails_800mmFoldHingedDown32mmGrabRail_BC5083-06_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5083-06:DP670300; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 498.5 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 498.5 mm
Dimensions - Area: 0.124379 m2; Volume: 0.00165807 m3
Identity Data - Mark: 2
Other - Family: BC5083-06: DP670300; Family and Type: BC5083-06: DP670300; Type: BC5083-06: DP670300; Type Id: BC5083-06: DP670300
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:356953
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-101
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror
Type - Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Pr_25_71_53_06:Bathroom mirrors
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 0; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 13
Other - Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:356952
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 2500 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-121
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit
Type - Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 12
Other - Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC725
Type - Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Pr_40_30_78_15:Clothes hooks
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: New Construction
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356954 | 1050 | 14
356955 | 1400 | 15

# IfcFlowTerminal: BC727:BC727, BC727:BC727:356944
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 133 mm; Height: 391 mm; Width: 88 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_86:Toilet brush holders; CodePerformance: n/a; Color: Brush Satin or RALPowdercoated; Constituents: n/a; Description: Toilet brush holder; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brush Satin or RALPowdercoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC727/BC727PC; ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; NBSDescription: Toilet brush holders; NBSReference: 45-35-72/364; NBSTypeID: n/a; NominalHeight: 391; NominalLength: 133; NominalWidth: 88; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-brush-set-bc727/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 88 x 391 x 133 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC727; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Title: Toilet brush holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC727
Type - Pset_ElementShading - Color: Brush Satin or RALPowdercoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; Category: Pr_40_20_76_86:Toilet brush holders
Pset_DistributionFlowElementCommon - Reference: BC727:BC727; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 100 mm; Host: Level : Level 0; Offset from Host: 100 mm
Dimensions - Area: 0.0857889 m2; Volume: 0.000302901 m3
Identity Data - Mark: 4
Other - Family: BC727: BC727; Family and Type: BC727: BC727; Type: BC727: BC727; Type Id: BC727: BC727
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin, BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin:356949
In: Level 0
Type - Material: Default (6)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 170 mm; Height: 542 mm; Width: 282 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 24 litres; Category: Pr_40_50_07_96:WasteBins; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Plastic liner; Finish: Brushed Satin; Form: WallOrFloorMounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC951; ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin; Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; NBSDescription: Waste bins; NBSReference: 45-35-72/380; NBSTypeID: n/a; NominalHeight: 542; NominalLength: 170; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.31.11; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-free-standing-surface-mounted-bin/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 282 x 542 x 170 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Uniclass2015Code: Pr_40_50_07_96; Uniclass2015Title: Waste bins; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC951
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin
Type - Pset_ProductRequirements - Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; Category: Pr_40_50_07_96:WasteBins
Pset_DistributionFlowElementCommon - Reference: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 0; Offset from Host: 0 mm
Dimensions - Area: 0.535081 m2; Volume: 0.000583357 m3
Identity Data - Mark: 9
Other - Family: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Family and Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type Id: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC958:BC958, BC958:BC958:1094361
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103 mm; Height: 369 mm; Width: 281.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_62:Paper towel dispensers; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; Description: Paper towel dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Locakble; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlesSteel; ModelNumber: BC958; ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; NBSDescription: Paper towel dispensers; NBSReference: 45-35-72/344; NBSTypeID: n/a; NominalHeight: 369; NominalLength: 103; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.17; Operation: Pull-out; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-paper-towel-dispenser-bc958/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 282 x 369 x 103 mm; SustainabilityPerformance: n/a; TagNumber: n/a; TowelCapacity: 400; Type Name: BC958; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC958
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; Category: Pr_40_70_22_62:Paper towel dispensers
Pset_DistributionFlowElementCommon - Reference: BC958:BC958; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1000 mm; Host: Level : Level 0; Offset from Host: 1000 mm
Dimensions - Area: 0.176441 m2; Volume: 0.01063 m3
Identity Data - Mark: 645
Other - Family: BC958: BC958; Family and Type: BC958: BC958; Type: BC958: BC958; Type Id: BC958: BC958
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB784.1:DB784.1, DB784.1:DB784.1:1094363
In: Level 0
Type - PredefinedType: WASTETRAP; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 160 mm; Length: 320.25 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: BS EN 274-1:2002 and Approved Document H; Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Waste Trap; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4" Waste_75mmWaterSeal; Finish: Suffix_SS-316BrushedSatin; Grade: 316; IfcExportAs: IfcWasteTerminalType; IfcExportType: WASTETRAP; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: DB784.1; ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Name: WasteTrap_Blue_SatinSS316_DB784.1_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NBSTypeID: n/a; NominalHeight: 160; NominalLength: 320; NominalWidth: 32; ObjectClassification: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: DB784.1; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Size: 160x320x32; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB784.1; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB784.1
Type - Pset_ElementShading - Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteTrap_Blue_SatinSS316_DB784.1_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB784.1:DB784.1; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 440 mm; Host: Level : Level 0; Offset from Host: 440 mm
Dimensions - Area: 0.0645665 m2; Volume: 0.000375945 m3
Identity Data - Mark: 647
Other - Family: DB784.1: DB784.1; Family and Type: DB784.1: DB784.1; Type: DB784.1: DB784.1; Type Id: DB784.1: DB784.1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB793S:DB794S, DB793S:DB794S:1094364
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: n/a; Color: BrushedSatin or PowderCoatedRAL; Constituents: n/a; Description: Waste Drain; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4 waste_Slotted; Finish: BrushedChrome or PowderCoatedRAL; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB793S/DB793-PC; ModelReference: DolphinSolutionsLimited_WasteDrain; Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NominalHeight: 48mm; NominalLength: 0; NominalWidth: 63mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-blue-waste-drain/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 48 x 63 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB794S; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB793S
Type - Pset_ElementShading - Color: BrushedSatin or PowderCoatedRAL
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WasteDrain; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB793S:DB794S; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 661.735 mm; Host: Level : Level 0; Offset from Host: 661.735 mm
Dimensions - Area: 0.0175881 m2; Volume: 0.0000437176 m3
Identity Data - Mark: 648
Other - Family: DB793S: DB794S; Family and Type: DB793S: DB794S; Type: DB793S: DB794S; Type Id: DB793S: DB794S
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DC1500:DC1500, DC1500:DC1500:356960
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_97 : WC suites; CAWS: N13/10 WC pans and flushing arrangements_N13/300 WCs and cisterns; CodePerformance: EN997–CL2_DocM_LANTAC_BS8300; Color: White_Grey-Seat; Constituents: n/a; Description: WC Suite with close coupled cistern_Anti lateral seat retaining buffers-DC1510-GRY; DurationUnit: year; ExpectedLife: n/a; Features: 480ToSeat_DocMCompliant; Finish: Gloss; Form: FloorStanding_BackToWall; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: .CISTERN.TOILETPAN; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: Ceramic; ModelNumber: DC1500; ModelReference: DolphinSolutionsLimited_DocM_WCCloseCoupled; Name: DolphinSolutionsLimited_DocM_WCCloseCoupled_DC1500; NBSDescription: WC Suites; NBSReference: 45-35-70/380; NBSTypeID: n/a; NominalHeight: 870 mm; NominalLength: 750 mm; NominalWidth: 400 mm; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 870x750x400; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC1500; Uniclass2015Code: Pr_40_20_93_97; Uniclass2015Title: WC suites; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC1500
Type - Pset_ElementShading - Color: White_Grey-Seat
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DocM_WCCloseCoupled; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: DolphinSolutionsLimited_DocM_WCCloseCoupled_DC1500; Category: Pr_40_20_93_97 : WC suites
Pset_DistributionFlowElementCommon - Reference: DC1500:DC1500; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 595 mm; Host: Level : Level 0; Offset from Host: 595 mm
Dimensions - Area: 1.16548 m2; Volume: 0.0703824 m3
Identity Data - Mark: 20
Other - Family: DC1500: DC1500; Family and Type: DC1500: DC1500; Type: DC1500: DC1500; Type Id: DC1500: DC1500
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DC34.5025:DC34.5025R, DC34.5025:DC34.5025R:1094362
In: Level 0
Type - PredefinedType: WASHHANDBASIN; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 125 mm; Length: 500 mm; Width: 250 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_96_18 Countertop washbasins-Pr_40_20_96_96:Wall-hung wash basins; CAWS: N13/335 Washbasins_N13/30 Washbasins; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Wash basin wall hung or counter mounted rectangular with overflow; DurationUnit: year; ExpectedLife: n/a; Features: tap hole_overflow; Finish: Glossy; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WASHHANDBASIN; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: Ceramic; ModelNumber: DC34.5025; ModelReference: DolphinSolutionsLimited_Washbasin; Name: Washbasin_RectangularWithOverflow_DC34.5025_DolphinSolutionsLimited; NBSDescription: Countertop washbasins_Wall-hung wash basins; NBSReference: 35-70-70/124; NominalHeight: 125; NominalLength: 500; NominalWidth: 250; ObjectClassification: Omniclass; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; SerialNumber: n/a; Shape: Square; Size: 500w x 250d 125h mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC34.5025R; Uniclass2015Code: Pr_40_20_96_18-Pr_40_20_96_96; Uniclass2015Title: Countertop washbasins_Wall-hung wash basins; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC34.5025; Type: 34.5025R
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Washbasin; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Washbasin_RectangularWithOverflow_DC34.5025_DolphinSolutionsLimited; Category: Pr_40_20_96_18 Countertop washbasins-Pr_40_20_96_96:Wall-hung wash basins
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 152400 mm; NominalWidth: 76200 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: DC34.5025:DC34.5025R; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 595 mm; Host: Level : Level 0; Offset from Host: 595 mm
Dimensions - Area: 0.279762 m2; Volume: 0.00883039 m3
Identity Data - Mark: 646
Other - Family: DC34.5025: DC34.5025R; Family and Type: DC34.5025: DC34.5025R; Type: DC34.5025: DC34.5025R; Type Id: DC34.5025: DC34.5025R
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DS213.150.150:DS213.150.150, DS213.150.150:DS213.150.150:1094365
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP68 connector; Category: Pr_40_20_87_98:Washbasin Taps; CodePerformance: WRAS; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: InformBasinTap; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyRatedOperationalVoltage: Plug in 9v Transformers 100-240V; ExpectedLife: n/a; Features: Up to 70% water savings_BREEAM/ SKA/ LEED/ WELL/ WRAS/ compliant_Flow rate: Max. 3.0 litres/minute between 0.5 and 6.0 bar_Water supply: single inlet cold or pre-mixed � a TMV2 or TMV3 thermostatic mixing valve is recommended for premixed application; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Form: CounterMounted; Grade: 316; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DS213.150.150; ModelReference: DolphinSolutionsLimited_InformBsainTap; Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; NBSDescription: WashbasinTaps; NBSReference: 45-35-70/371; NBSTypeID: n/a; NominalHeight: 150 mm; NominalLength: 150 mm; NominalWidth: 22 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.17; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-inform-basin-tap-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 150 x 150 x 22 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DS213.150.150; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin Taps; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DS213.150.150
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_InformBsainTap; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; Category: Pr_40_20_87_98:Washbasin Taps
Pset_DistributionFlowElementCommon - Reference: DS213.150.150:DS213.150.150; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.0207593 m2; Volume: 0.0000445686 m3
Identity Data - Mark: 649
Other - AL0220: yes; Family: DS213.150.150: DS213.150.150; Family and Type: DS213.150.150: DS213.150.150; Type: DS213.150.150: DS213.150.150; Type Id: DS213.150.150: DS213.150.150
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC754:BC754, BC754:BC754:1094366
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 200 mm; Height: 50 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_78:Shelves; CAWS: N13/449 Shelves; CodePerformance: n/a; Color: Brushed Satin_RAL Colours; Constituents: n/a; Description: Shelf; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin_PowderCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: Shelf; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC754; ModelReference: DolphinSolutionsLimited_Shelf; Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; NBSDescription: Shelves; NBSReference: 45-35-80/320; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 400; NominalWidth: 200; ObjectClassification: 23.40.20.27.11; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 200 x 400 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC754; Uniclass2015Code: Pr_40_30_78_78; Uniclass2015Title: Shelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC754
Type - Pset_ElementShading - Color: Brushed Satin_RAL Colours
Type - Pset_FurnitureTypeCommon - Description: Shelf; NominalHeight: 15240 mm; NominalLength: 121920 mm
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Shelf; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; Category: Pr_40_30_78_78:Shelves
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC754:BC754
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 710 mm; Host: Level : Level 0; Offset from Host: 710 mm
Dimensions - Area: 0.126358 m2; Volume: 0.000250292 m3
Identity Data - Mark: 650
Other - Family: BC754: BC754; Family and Type: BC754: BC754; Type: BC754: BC754; Type Id: BC754: BC754
Phasing - Phase Created: New Construction

# IfcRailing: BC5083-05:BC5083-05, BC5083-05:BC5083-05:1094367
In: Level 0
Type - PredefinedType: HANDRAIL; Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Heigth: 92 mm; Length: 500 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CAWS: N13/69 Support rails and grab bars_N13/436 Handrails and grab bars; CodePerformance: BSEN12182; Color: Brushed Satin_Various; Constituents: n/a; Description: 500mm long flanged 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Flanged 60mm wall clearance; Finish: Brushed Satin_Suffix.5-PowderCoated_.6-CeramicCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcRailingType; IfcExportType: HANDRAIL; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC5083-05; ModelReference: DolphinSolutionsLimited_Flanged32mmGrabRail; Name: SupportRails_Flanged32mmGrabRail_BC5083-05_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 500 mm; NominalWidth: 32 mm; ObjectClassification: 23.40.20.27.14; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-05; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-05
Type - Pset_ElementShading - Color: Brushed Satin_Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Flanged32mmGrabRail; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: SupportRails_Flanged32mmGrabRail_BC5083-05_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Type - Pset_RailingCommon - IsExternal: no
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-05:BC5083-05
Pset_RailingCommon - Reference: BC5083-05:BC5083-05
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664 mm; Host: Level : Level 0; Offset from Host: 664 mm
Dimensions - Area: 0.0552755 m2; Volume: 0.000548794 m3
Identity Data - Mark: 651
Other - Family: BC5083-05: BC5083-05; Family and Type: BC5083-05: BC5083-05; Type: BC5083-05: BC5083-05; Type Id: BC5083-05: BC5083-05
Phasing - Phase Created: New Construction
